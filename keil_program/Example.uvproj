# Keil uVision project Example.uvproj, settings and files
target Project (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: Example +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\Lib\inc;.\Lib;.\User
  group STARUP
    ./: STARTUP.A51
  group User
    ./User/: main.c
  group LIB
    ./Lib/: Lib_config.h
    ./Lib/src/: IIC.c
    ./Lib/inc/: IIC.h
  group ADC
    ./Lib/src/: ADC0832.c
  group DISPLAY
    ./Lib/src/: LCD1602.c
  group EEPROM
    ./Lib/src/: 24C02.c
    ./Lib/inc/: 24C02.h
